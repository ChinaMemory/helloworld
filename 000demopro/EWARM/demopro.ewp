# IAR project demopro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demopro.hex
  ILINK.IlinkOutputFile: dg142872.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c
  group User
    ../User/: bsp.c delay.c main.c out.c
